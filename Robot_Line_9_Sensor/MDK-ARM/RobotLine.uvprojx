# Keil uVision project RobotLine.uvprojx, settings and files
target RobotLine_F103C8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RobotLine +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB
  c misc: --c99
  c include: ..\App;..\BSP;..\Config;..\Control;..\Drivers;..\ThirdParty\CMSIS\Include;..\ThirdParty\CMSIS\Device\ST\STM32F1xx\Include;..\ThirdParty\FreeRTOS\include;..\ThirdParty\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\RobotLine.sct
  group Application
    ../App/: main.c robot.c robot.h monitor.c
  group Control
    ../Control/: tracker.c tracker.h drive.c drive.h
  group Config
    ../Config/: robot_config.h sensor_map.h sensor_calibration.h board_config.h FreeRTOSConfig.h
  group Board
    ../BSP/: board.c
  group Drivers
    ../Drivers/: line_sensor.c motor_driver.c oled.c i2c_soft.c uart_debug.c user_io.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group FreeRTOS
    ../ThirdParty/FreeRTOS/: tasks.c list.c queue.c
    ../ThirdParty/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../ThirdParty/FreeRTOS/portable/MemMang/: heap_4.c
